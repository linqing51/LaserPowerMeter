# Keil uVision project LaserPowerMeter.uvproj, settings and files
target Debug (MCS-51)
  device: C8051F350 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(50000000)
  output: LaserPowerMeter +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F350
  c include: .\Lib;.\MainApp
  group Lib
    ./Lib/: STARTUP.A51
  group MainApp
    ./MainApp/: InitDevice.c MainApp.c ModbusPort.c Modbus.c
